# Keil uVision project Lab_6.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131 Microchip
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: Lab_6 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Musical_Notes.c lab6_1.c lab6_2.c
