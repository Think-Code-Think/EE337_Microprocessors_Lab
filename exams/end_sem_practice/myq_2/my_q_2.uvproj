# Keil uVision project my_q_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131 Microchip
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: my_q_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 serial.h Q2.c lcd.h
